# Keil uVision project f407-reg-lab.uvprojx, settings and files
target f407-reg-lab (5060750)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") ELITTLE
  output: f407-reg-lab +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F407xx
  c include: ..\User;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  group User
    ../User/: main.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
